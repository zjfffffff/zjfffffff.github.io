# Keil uVision project SweepFrequency.uvprojx, settings and files
target SweepFrequency (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SweepFrequency +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\User;..\Libraries;..\StepSingle
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: aaa.c main.c AngelCalculation.c AngelCalculation1.c AttitudeAlgorithm.c CalculatesLocation.c can.c DyCnvertCoordinate1.c elmo.c ELMOTEST.c encode.c EXIT.c extiz.c FSMC.c FsmCompensator.c FsmCompensator_servo.c GuanDaoZhuanHuan.c ioinit.c MotorOutputPosse.c PointFunction.c PositionLoop.c ServoFunction.c ScanFunction.c stm32f4xx_it.c stmflash.c TestFunction.c TestScan.c timer.c YunSuFunction.c FY_485.c AHRS_100A.c ASCII.c Camera_Config.c RMS.c PC_Communication.c RMS2.c Comm1_Communication.c SaoMiao.c temperature.c usart.c Receive_Send_Data.c Deg_InverseSolution.c WriteGuanDao.c
  group Start
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Std_Phe
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group StepSingle
    ../StepSingle/: StepSingle.c
